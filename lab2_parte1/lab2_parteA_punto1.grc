options:
  parameters:
    author: Daniela_Cabrales_Brayan_Fonseca_L1C_G2
    copyright: Daniela_Cabrales_Brayan_Fonseca_L1C_G2
    generate_options: qt_gui
    id: lab2_parteA_punto1
    output_language: python
    title: Configuracion USRP
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud de la señal TX
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '500e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora fc
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: A
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
