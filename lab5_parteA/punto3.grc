options:
  parameters:
    author: Daniela_Brayan
    copyright: Daniela_Brayan
    generate_options: qt_gui
    id: multiplexaPAM
    output_language: python
    title: multiplexaPAM
  states: {}

blocks:
- name: LPF
  id: variable_qtgui_range
  parameters:
    label: frecuencia corte filtro
    start: '0'
    step: '10'
    stop: '1000'
    value: '100'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: d
  id: variable_qtgui_range
  parameters:
    label: ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: d1
  id: variable_qtgui_range
  parameters:
    label: retardo 1
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    label: retardo 2
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    label: retardo 3
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: d4
  id: variable_qtgui_range
  parameters:
    label: retardo 4
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: '1000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: frecuencia pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModulacionPAM_0
  id: ModulacionPAM
  parameters:
    D: d
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_0
  id: ModulacionPAM
  parameters:
    D: d
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_1
  id: ModulacionPAM
  parameters:
    D: d
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_1_0
  id: ModulacionPAM
  parameters:
    D: d
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1
  id: ModulacionPAM
  parameters:
    D: d
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: d4
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LPF
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_0
    type: fcc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    samp_rate: samp_rate_0
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [ModulacionPAM_0, '0', blocks_add_xx_0, '0']
- [ModulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModulacionPAM_0_0, '0', blocks_delay_0, '0']
- [ModulacionPAM_0_1, '0', blocks_delay_1, '0']
- [ModulacionPAM_0_1_0, '0', blocks_delay_2, '0']
- [ModulacionPAM_1, '0', low_pass_filter_0, '0']
- [ModulacionPAM_1, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_1, '0', ModulacionPAM_0_0, '0']
- [analog_sig_source_x_2, '0', ModulacionPAM_0_1, '0']
- [analog_sig_source_x_3, '0', ModulacionPAM_0_1_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_3, '0', ModulacionPAM_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '1']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
