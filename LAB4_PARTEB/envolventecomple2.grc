options:
  parameters:
    author: Daniela_Brayan
    copyright: Daniela_Brayan
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulacion_PM
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    orient: Qt.Horizontal
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: coeficiente kp
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/2
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    I_vect: '1024'
  states: {}
- name: Envolvente_compleja_L1C_0
  id: Envolvente_compleja_L1C
  parameters:
    ac: ac
    kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_compleja_L1C_0, '0', blocks_complex_to_real_0, '0']
- [Envolvente_compleja_L1C_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_compleja_L1C_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_compleja_L1C_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_compleja_L1C_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
